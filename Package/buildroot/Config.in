## Package/buildroot/Config.in
```kconfig
config BR2_PACKAGE_LIBIOPCCOMMON
	bool "libiopccommon"
	select BR2_PACKAGE_JSON_C
	help
	  The common library of IOPC.
```
